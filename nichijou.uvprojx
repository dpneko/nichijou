# Keil uVision project nichijou.uvprojx, settings and files
target nichijou (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nichijou +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F4XX
  c include: .\Lib\inc;.\Lib\Include;.\StartUp;.\User_Src;.\HardWareDriver\ADC;.\HardWareDriver\AT45DB;.\HardWareDriver\SPI3;.\HardWareDriver\GCS_Protocol;.\HardWareDriver\GPS;.\HardWareDriver\IMU;.\HardWareDriver\LED;.\HardWareDriver\Math;.\HardWareDriver\MS5611;.\HardWareDriver\PWM_Input;.\HardWareDriver\PWM_Output;.\HardWareDriver\Quadrotor;.\HardWareDriver\Service;.\HardWareDriver\UART1;.\HardWareDriver\Ultrasonic;.\config;.\HardWareDriver\PID;.\HardWareDriver\USART_DMA;.\HardWareDriver\LSM303D;.\FatFs;.\HardWareDriver\MPU6500;.\HardWareDriver\Camera;.\HardWareDriver\UART4;.\HardWareDriver\AltitudeFilter
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./StartUp/: startup_stm32f4xx.s system_stm32f4xx.c
  group Lib
    ./Lib/src/: stm32f4xx_wwdg.c misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dcmi.c stm32f4xx_rng.c stm32f4xx_sdio.c stm32f4xx_rtc.c
  group User
    ./User_Src/: main.c stm32f4xx_it.c
  group HardWareDriver
    ./HardWareDriver/ADC/: STM32ADC.c
    ./HardWareDriver/AT45DB/: AT45DB.c
    ./HardWareDriver/GPS/: GPS.c
    ./HardWareDriver/IMU/: IMU.c
    ./HardWareDriver/LED/: LED.c
    ./HardWareDriver/LSM303D/: LSM303D.c
    ./HardWareDriver/MPU6500/: MPU6500.c
    ./HardWareDriver/MS5611/: MS5611.c
    ./HardWareDriver/PWM_Input/: PWM_Input.c
    ./HardWareDriver/PWM_Output/: PWM_Output.c
    ./HardWareDriver/Service/: delay.c IOI2C.c
    ./HardWareDriver/UART1/: UART1.c
    ./HardWareDriver/Ultrasonic/: Ultrasonic.c
    ./HardWareDriver/Camera/: Camera.c
    ./HardWareDriver/UART4/: UART4.c
    ./HardWareDriver/SPI3/: SPI3.c
    ./HardWareDriver/AltitudeFilter/: AltitudeFilter.c
  group Quad
    ./HardWareDriver/GCS_Protocol/: GCS_Protocol.c
    ./HardWareDriver/Math/: Fmath.c
    ./HardWareDriver/PID/: Pid.c
    ./HardWareDriver/Quadrotor/: Quadrotor.c
  group UART_DMA
    ./HardWareDriver/USART_DMA/: OSQMem.c USART1DMATX.c
  group fatfs
    ./FatFs/: diskio.c FAT_driver.c ff.c SD_init.c
  group readme
    ./: readme.txt
    ./HardWareDriver/LED/: LED_readme.txt
    ./HardWareDriver/IMU/: IMU_readme.txt
    ./HardWareDriver/Quadrotor/: Quad_readme.txt
    ./HardWareDriver/GCS_Protocol/: GCS_readme.txt
